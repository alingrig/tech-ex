RDEPENDS:${PN}:remove = " \
    kernel-module-loop \
    kernel-module-algif-hash \
    kernel-module-scsi-debug \
    kernel-module-uvesafb \
    kernel-module-scsi-debug \
    packagegroup-core-boot \
    udev \
"
